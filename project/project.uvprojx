# Keil uVision project project.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: stepper.c common.h common.c main.c stepper.h fsr.h p9813.h forceSensorCall.c p9813Call.c conveyor_belt.c light_beam.c MCP23S08.c conveyor_belt.h light_beam.h MCP23S08.h
software components: CMSIS:CORE 6.1.1, Device:Startup 2.6.3
