# Keil uVision project hall_effect.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F446MCYx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hall_effect
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: hall_effect.h hall_effect.c main.c
software components: CMSIS:CORE 6.2.0, Device:Startup 2.6.3
